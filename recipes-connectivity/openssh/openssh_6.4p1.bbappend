FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"
# Don't forget to bump PRINC if you update the extra files.
PRINC = "1"
