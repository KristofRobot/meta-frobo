FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

#PV = "3.4.103"
#PR = "r1"
#SRCREV_pn-${PN} = "9a1cd034181af628d4145202289e1993c1687db6"
