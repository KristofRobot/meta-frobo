FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PV = "3.4.104"
PR = "r0"
SRCREV_pn-${PN} = "a8f8ba9ba383c2358d67b4dcaa5ce5cd4f0dd587"
