FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

#set hostname
hostname = "frobo"
